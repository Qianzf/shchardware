# Keil uVision project design.uvprojx, settings and files
target 毕业设计 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: design
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX MANGUSTA_DISCOVERY USE_USB_OTG_FS HSE_VALUE=8000000
  c include: ..\uCOSII\CORE;..\uCOSII\PORT;..\uCOSII\CONFIG;..\FWLIB\inc;..\USER;..\CONFIG\inc;..\SOFTWARE\inc;..\CORE;..\APP\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/src/: app_exec.c LED_Effect.c ttl_display.c utils.c WiFiListener.c WiFiInit.c test.c gui.c display.c
    ../USER/: stm32f4xx_it.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group USER
    ../USER/: main.c system_stm32f4xx.c
  group CONFIG
    ../CONFIG/src/: gpio_init.c usart.c lcd.c
  group uCOSII_SOURCE
    ../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII_CFG
    ../uCOSII/CONFIG/: includes.h os_cfg.h
  group uCOSII_PORT
    ../uCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
